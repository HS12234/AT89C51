# Keil uVision project memo.uvproj, settings and files
target Demo (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: memo +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\User
  group Startup
    ../Startup/: STARTUP.A51
  group User
    ../User/: main.c interrupt.c bsp_key.c
