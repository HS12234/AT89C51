# Keil uVision project Demo.uvproj, settings and files
target Demo (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: Demo +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\User
  group Startup
    ./: STARTUP.A51
  group User
    ../User/: main.c bsp_I2C.c bsp_LED_1602A.c bsp_AT24C02.c
